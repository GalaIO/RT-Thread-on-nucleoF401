# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32f4xx +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F401xx,STM32F401xE,MOTION_DRIVER_TARGET_RTTHREAD_STM32F4,MPU6050,
  c include: .;..\components\finsh;..\include;..\libcpu\arm\common;..\libcpu\arm\cortex-m4;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\CMSIS\Include;Libraries\CMSIS\ST\STM32F4xx\Include;Libraries\STM32F4xx_StdPeriph_Driver\inc;applications;drivers;.\BSP;.\eMPL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c startup.c
    ./applications/: dmp_task.c finish_cmd.c 2401_task.c
  group Drivers
    drivers/: board.c serial.c stm32f4xx_it.c usart.c
    ./: rtconfig.h rtuser.h rtusing.h
    ./drivers/: board.h stm32f4xx_conf.h rtc.c rtc.h serial.h usart.h rt_printf.c rt_scanf.c GFifo.h mpu6050_dmp.c mpu6050_dmp.h filter.c filter.h PID.c PID.h nrf2401.c nrf2401.h
    ../include/: rtdebug.h
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s
    ./Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_dbgmcu.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_gpio.h stm32f4xx_i2c.h stm32f4xx_rcc.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_pwr.c
  group Kernel
    ./: rtusing.h
    ../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group CORTEX-M4
    ../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group finsh
    ../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group BSP
    ./BSP/: bsp_gpio.c bsp_gpio.h bsp_user.h bsp_sys.c bsp_sys.h bsp_exti.c bsp_exti.h bsp_timer.c bsp_timer.h bsp_rtc.c bsp_rtc.h bsp_adc.c bsp_adc.h bsp_flash.c bsp_flash.h bsp_iic1.h bsp_iic1.c bsp_mpu6050.c bsp_mpu6050.h bsp_spi1.c bsp_spi1.h bsp_24l01.c bsp_24l01.h
  group eMPL
    ./eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
software components: CMSIS:CORE 4.1.0
